# Keil uVision project STC_Demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: BSP_Demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group Source Group 1
    ./source/: main.c STCBSP_V3.6.LIB
    ./inc/: DS1302.h displayer.h FM_Radio.h
